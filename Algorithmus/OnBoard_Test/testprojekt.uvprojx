# Keil uVision project testprojekt.uvprojx, settings and files
target testprojekt (6090000::V6.9::.\ARMCLANG)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: testprojekt
  AfterMake: fromelf --bin --output bin\testprojekt.bin bin\testprojekt.axf
  AfterMake: fromelf -cedrst --output bin\testprojekt.txt bin\testprojekt.axf
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO2 keil
  c include: ../../MCU/bsp;../../MCU/utils;../../MCU/devices;../../MCU/mcu/apollo2;../
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: testprojekt.sct
  link misc: ../../MCU/mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ./: testprojekt.c
    ../: BlackmanNuttall.c CyclicShift.c FFT.c Hanning.c Lowpass.c Utils.c BlackmanNutall.h CyclicShift.h FFT.h Hanning.h Lowpass.h Utils.h
  group utils
    ../../MCU/utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil
    ./: startup_keil.s
  group lib
    ../../MCU/bsp/keil/bin/: libam_bsp.lib
    ../../MCU/mcu/apollo2/hal/keil/bin/: libam_hal.lib
