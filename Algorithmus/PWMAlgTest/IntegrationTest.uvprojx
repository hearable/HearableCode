# Keil uVision project IntegrationTest.uvprojx, settings and files
target IntegrationTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: IntegrationTest
  AfterMake: fromelf --bin --output bin\IntegrationTest.bin bin\IntegrationTest.axf
  AfterMake: fromelf -cedrst --output bin\IntegrationTest.txt bin\IntegrationTest.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_DEBUG_PRINTF AM_PART_APOLLO2 AM_FREERTOS keil
  c include: ../../MCU/bsp;../../MCU/utils;../../MCU/devices;../../MCU/mcu/apollo2;./RTOS/include;./RTOS/portable/KEIL/AMApollo2;./Algorithmus/
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: IntegrationTest.sct
  link misc: ../../MCU/mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --info sizes
  group MemMang
    ../../MCU/third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
  group src
    ./: IntegrationTest.c rtos.c
  group utils
    ../../MCU/utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ./: startup_keil.s
  group lib
    ../../MCU/bsp/keil/bin/: libam_bsp.lib
    ../../MCU/mcu/apollo2/hal/keil/bin/: libam_hal.lib
  group Headers
    ./RTOS/include/: FreeRTOSConfig.h StackMacros.h FreeRTOS.h
    ./RTOS/portable/Keil/AMapollo2/: portmacro.h
  group AMApollo2
    ./RTOS/portable/Keil/AMapollo2/: port.c
  group RTOS
    ./RTOS/: event_groups.c list.c queue.c tasks.c timers.c
  group Algorithmus
    ./Algorithmus/: BlackmanNuttall.c CyclicShift.c FFT.c Hanning.c Lowpass.c Utils.c
